/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationClockDrop.cpp
 *      \brief      
 *
 *      \details    
 *                  
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_DROP_SOURCE_

/******************************************************************************************************************************************************
 * INCLUDES
******************************************************************************************************************************************************/
#include "AnimationClockDrop.h"


/******************************************************************************************************************************************************
 *  LOCAL CONSTANT MACROS
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  LOCAL FUNCTION MACROS
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  LOCAL DATA TYPES AND STRUCTURES
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Constructor of AnimationClockDrop
******************************************************************************************************************************************************/
/*! \brief          AnimationClockDrop Constructor
 *  \details        Instantiation of the AnimationClockDrop library
 *
 *  \return         -
******************************************************************************************************************************************************/
AnimationClockDrop::AnimationClockDrop()
{
    pDisplay = nullptr;
    pClock = nullptr;
    reset();
} /* AnimationClockDrop */


/******************************************************************************************************************************************************
  Destructor of AnimationClockDrop
******************************************************************************************************************************************************/
AnimationClockDrop::~AnimationClockDrop()
{

} /* ~AnimationClockDrop */


/******************************************************************************************************************************************************
  init()
******************************************************************************************************************************************************/
/*! \brief          
 *  \details        
 *                  
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::init(Display* Display, Clock* Clock)
{
    pDisplay = Display;
    pClock = Clock;
    setState(AnimationClockCommon::STATE_IDLE);
    reset();
} /* init */


/******************************************************************************************************************************************************
  setClock()
******************************************************************************************************************************************************/
/*! \brief          
 *  \details        
 *                  
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockDrop::setClock(byte Hour, byte Minute)
{
    stdReturnType ReturnValue{E_NOT_OK};

    if(pClock->getClockWords(Hour, Minute, ClockWordsTable) == E_OK && getState() == AnimationClockCommon::STATE_IDLE) {
        setNextWordIndex();
        if(setNextActivePixelIndex() == E_NOT_OK) { setStateToSetTime(); }
        else { setState(AnimationClockCommon::STATE_CLEAR_TIME); }
    }
    return ReturnValue;
} /* setClock */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
/*! \brief          
 *  \details        
 *                  
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::task()
{
    if(getState() == AnimationClockCommon::STATE_CLEAR_TIME) { clearTimeTask(); }
    if(getState() == AnimationClockCommon::STATE_SET_TIME) { setTimeTask(); }
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::reset()
{
    Row = 0;
    Column = 0;
    CurrenWordIndex = CLOCK_WORDS_TABLE_TYPE_SIZE - 1;
} /* reset */


/******************************************************************************************************************************************************
  clearTimeTask()
******************************************************************************************************************************************************/
/*! \brief          
 *  \details        
 *                  
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::clearTimeTask()
{
    // toggle current Pixel
    if(Row < DISPLAY_NUMBER_OF_ROWS && Column < DISPLAY_NUMBER_OF_COLUMNS) { pDisplay->togglePixelFast(Column, Row); }
    // increment row and check for out of bounds
    if(Row + 1 < DISPLAY_NUMBER_OF_ROWS) {
        // toggle Pixel in next row
        Row++;
        pDisplay->togglePixelFast(Column, Row);
    } else {
        // no more active pixels available
        if(setNextActivePixelIndex() == E_NOT_OK) { setStateToSetTime(); }
    }
} /* clearTimeTask */


/******************************************************************************************************************************************************
  setTimeTask()
******************************************************************************************************************************************************/
/*! \brief          
 *  \details        
 *                  
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::setTimeTask()
{
    DisplayWords::WordType CurrentWord = Words.getDisplayWordFast(ClockWordsTable[CurrenWordIndex]);
    const byte MaxColumn = Words.getDisplayWordColumnFast(ClockWordsTable[CurrenWordIndex]) + CurrentWord.Length - 1;

    if(setNextRow(CurrentWord.Row) == E_OK) {
        pDisplay->clearPixelFast(Column, Row - 1);
    } else {
        if(setNextColumn(MaxColumn) == E_NOT_OK) {
            setState(AnimationClockCommon::STATE_IDLE);
        }
    }
    pDisplay->setPixelFast(Column, Row);
} /* setTimeTask */


/******************************************************************************************************************************************************
  getNextActivePixel()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockDrop::setNextActivePixelIndex()
{
    for(int16_t Index = DISPLAY_NUMBER_OF_PIXELS - 1; Index >= 0; Index--) {
        if(pDisplay->getPixelFast(Index)) {
            pDisplay->indexToColumnAndRow(Index, Column, Row);
            return E_OK;
        }
    }
    return E_NOT_OK;
}


/******************************************************************************************************************************************************
  setNextWordIndex()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockDrop::setNextWordIndex()
{
    for(int8_t Index = CurrenWordIndex - 1; Index >= 0; Index--) {
        if(ClockWordsTable[Index] != DisplayWords::WORD_NONE) {
            CurrenWordIndex = Index;
            return E_OK;
        }
    }
    return E_NOT_OK;
} /* setNextWordIndex */


/******************************************************************************************************************************************************
  setStateToSetTime()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockDrop::setStateToSetTime()
{
    Column = Words.getDisplayWordColumnFast(ClockWordsTable[CurrenWordIndex]);
    pDisplay->setPixelFast(Column, Row);
    setState(AnimationClockCommon::STATE_SET_TIME);
} /* setStateToSetTime */


/******************************************************************************************************************************************************
  setNextRow()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockDrop::setNextRow(byte MaxRow)
{
    if(Row >= MaxRow) {
        return E_NOT_OK;
    } else {
        Row++;
        return E_OK;
    }
} /* setNextRow */


/******************************************************************************************************************************************************
  setNextColumn()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockDrop::setNextColumn(byte MaxColumn)
{
    if(Column >= MaxColumn) {
         if(setNextWordIndex() == E_OK) {
            Column = Words.getDisplayWordColumnFast(ClockWordsTable[CurrenWordIndex]);
            Row = 0;
            return E_OK;
        } else {
            return E_NOT_OK;
        }
    } else {
        Column++;
        Row = 0;
        return E_OK;
    }
} /* setNextColumn */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
 