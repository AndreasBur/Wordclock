/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationClockExplode.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_EXPLODE_SOURCE_

/******************************************************************************************************************************************************
 * INCLUDES
******************************************************************************************************************************************************/
#include "AnimationClockExplode.h"


/******************************************************************************************************************************************************
 *  LOCAL CONSTANT MACROS
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  LOCAL FUNCTION MACROS
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  LOCAL DATA TYPES AND STRUCTURES
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  init()
******************************************************************************************************************************************************/
void AnimationClockExplode::init()
{
    AnimationClockCommon::init(STATE_IDLE);
    reset();
} /* init */


/******************************************************************************************************************************************************
  setTime()
******************************************************************************************************************************************************/
StdReturnType AnimationClockExplode::setTime(byte Hour, byte Minute)
{
    StdReturnType ReturnValue{E_NOT_OK};

    if(Clock::getInstance().getClockWords(Hour, Minute, ClockWordsTable) == E_OK && State == STATE_IDLE) {
        ReturnValue = E_OK;
        if(setNextWordToClear() == E_OK) { State = STATE_CLEAR_TIME; }
        else { State = STATE_SET_TIME; }
    }
    return ReturnValue;
} /* setTime */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
void AnimationClockExplode::task()
{
    if(State == STATE_CLEAR_TIME) clearTimeTask();
    else if(State == STATE_SET_TIME) setTimeTask();
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
void AnimationClockExplode::reset()
{
    ClockWordsTable.fill(DisplayWords::WORD_NONE);
    ClockWordsTableIndex = 0u;
    CurrentWordIndex = 0u;
    CurrentWordLength = 0u;
    Column = 0u;
    Row = 0u;
} /* reset */

/******************************************************************************************************************************************************
  clearTimeTask()
******************************************************************************************************************************************************/
void AnimationClockExplode::clearTimeTask()
{
    if(shiftWord(getClearFinalColumn(), getClearFinalRow()) == E_NOT_OK) {
        toggleWordOnDisplay();
        if(setNextWordToClear() == E_NOT_OK) {
            CurrentWordIndex = 0u;
            setWordToSet(ClockWordsTable[CurrentWordIndex]);
            setWordOnDisplay();
            State = STATE_SET_TIME;
        }
    }
} /* clearTimeTask */

/******************************************************************************************************************************************************
  setTimeTask()
******************************************************************************************************************************************************/
void AnimationClockExplode::setTimeTask()
{
    if(shiftWord(getSetFinalColumn(), getSetFinalRow()) == E_NOT_OK) {
        if(setNextWordToSet() == E_NOT_OK) { State = STATE_IDLE; }
        else { toggleWordOnDisplay(); }
    }
} /* setTimeTask */

/******************************************************************************************************************************************************
  shiftWord()
******************************************************************************************************************************************************/
StdReturnType AnimationClockExplode::shiftWord(byte FinalColum, byte FinalRow)
{
    if(Column != getColumnNext(FinalColum) || Row != getRowNext(FinalRow)) {
        toggleWordOnDisplay();
        Column = getColumnNext(FinalColum);
        Row = getRowNext(FinalRow);
        toggleWordOnDisplay();
        return E_OK;
    } else {
        return E_NOT_OK;
    }
} /* shiftWord */

/******************************************************************************************************************************************************
  toggleWordOnDisplay()
******************************************************************************************************************************************************/
void AnimationClockExplode::toggleWordOnDisplay()
{
    for(byte columnIndex = Column; columnIndex < Column + CurrentWordLength; columnIndex++) {
        Display::getInstance().togglePixelFast(columnIndex, Row);
    }
} /* toggleWordOnDisplay */

/******************************************************************************************************************************************************
  setWordOnDisplay()
******************************************************************************************************************************************************/
void AnimationClockExplode::setWordOnDisplay()
{
    for(byte columnIndex = Column; columnIndex < Column + CurrentWordLength; columnIndex++) {
        Display::getInstance().setPixelFast(columnIndex, Row);
    }
} /* setWordOnDisplay */

/******************************************************************************************************************************************************
  setNextWordToClear()
******************************************************************************************************************************************************/
StdReturnType AnimationClockExplode::setNextWordToClear()
{
    for(byte nextWordIndex = CurrentWordIndex + CurrentWordLength; nextWordIndex < DISPLAY_NUMBER_OF_PIXELS; nextWordIndex++) {
        if(Display::getInstance().getPixelFast(nextWordIndex)) {
            CurrentWordIndex = nextWordIndex;
            setWordLength();
            Column = Display::getInstance().indexToColumn(CurrentWordIndex);
            Row = Display::getInstance().indexToRow(CurrentWordIndex);
            return E_OK;
        }
    }
    return E_NOT_OK;
} /* setNextWordToClear */

/******************************************************************************************************************************************************
  setNextWordToSet()
******************************************************************************************************************************************************/
StdReturnType AnimationClockExplode::setNextWordToSet()
{
    for(byte index = ClockWordsTableIndex + 1u; index < ClockWordsTable.size(); index++) {
        if(ClockWordsTable[index] != DisplayWords::WORD_NONE) {
            ClockWordsTableIndex = index;
            setWordToSet(ClockWordsTable[ClockWordsTableIndex]);
            return E_OK;
        }
    }
    return E_NOT_OK;
} /* setNextWordToSet */

/******************************************************************************************************************************************************
  setWordToSet()
******************************************************************************************************************************************************/
void AnimationClockExplode::setWordToSet(DisplayWords::WordIdType WordId)
{
    setWordIndex(WordId);
    CurrentWordLength = Words.getDisplayWordLengthFast(WordId);
    Column = getClearFinalColumn();
    Row = getClearFinalRow();
}

/******************************************************************************************************************************************************
  setWordIndex()
******************************************************************************************************************************************************/
void AnimationClockExplode::setWordIndex(DisplayWords::WordIdType WordId)
{
    byte Column = Words.getDisplayWordColumnFast(WordId);
    byte Row = Words.getDisplayWordRowFast(WordId);
    CurrentWordIndex = Display::getInstance().columnAndRowToIndex(Column, Row);
}

/******************************************************************************************************************************************************
  setWordLength()
******************************************************************************************************************************************************/
void AnimationClockExplode::setWordLength()
{
    CurrentWordLength = 1u;

    for(byte index = CurrentWordIndex + 1u; index < DISPLAY_NUMBER_OF_PIXELS; index++) {
        if(Display::getInstance().getPixelFast(index)) {
            CurrentWordLength++;
        } else {
            break;
        }
    }
}

/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
