/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationClockCube.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_CUBE_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "AnimationClockCube.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Constructor of AnimationClockCube
******************************************************************************************************************************************************/
/*! \brief          AnimationClockCube Constructor
 *  \details        Instantiation of the AnimationClockCube library
 *
 *  \return         -
******************************************************************************************************************************************************/
AnimationClockCube::AnimationClockCube()
{
    reset();
} /* AnimationClockCube */


/******************************************************************************************************************************************************
  Destructor of AnimationClockCube
******************************************************************************************************************************************************/
AnimationClockCube::~AnimationClockCube()
{

} /* ~AnimationClockCube */


/******************************************************************************************************************************************************
  init()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::init(Display* Display, Clock* Clock)
{
    AnimationClockCommon::init(Display, Clock, STATE_IDLE);
    reset();
} /* init */


/******************************************************************************************************************************************************
  setClock()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockCube::setClock(byte Hour, byte Minute)
{
    stdReturnType ReturnValue{E_NOT_OK};

    if(pClock->getClockWords(Hour, Minute, ClockWordsTable) == E_OK && State == STATE_IDLE) {
        ReturnValue = E_OK;
        setMaxBorder();
        State = STATE_CLEAR_TIME;
    }
    return ReturnValue;
} /* setClock */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::task()
{
    if(State == STATE_CLEAR_TIME) { clearTimeTask(); }
    else if(State == STATE_SET_TIME) { setTimeTask(); }
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::reset()
{
    Border.ColumnStart = 0;
    Border.ColumnEnd = 0;
    Border.RowStart = 0;
    Border.RowEnd = 0;
} /* reset */


/******************************************************************************************************************************************************
  setStateToSetTime()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::setStateToSetTime()
{
    clearBorderPixels();
    State = STATE_SET_TIME;
    setMinBorder();
} /* setStateToSetTime */


/******************************************************************************************************************************************************
  clearTimeTask()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::clearTimeTask()
{
    switch(BorderState)
    {
        case BORDER_STATE_MAX:
            setBorderPixels();
            BorderState = BORDER_STATE_BETWEEN;
            break;
        case BORDER_STATE_BETWEEN:
            clearBorderPixels();
            if(decreaseBorder() == E_NOT_OK) {
                setStateToSetTime();
            } else {
                setBorderPixels();
            }
        default:
            break;
    }
} /* clearTimeTask */


/******************************************************************************************************************************************************
  setTimeTask()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::setTimeTask()
{
    switch(BorderState)
    {
        case BORDER_STATE_MIN:
            setBorderPixels();
            BorderState = BORDER_STATE_BETWEEN;
            break;
        case BORDER_STATE_BETWEEN:
            clearBorderPixelsWithoutClockPixels();
            if(increaseBorder() == E_NOT_OK) {
                State = STATE_IDLE;
            } else {
                setBorderPixels();
            }
        default:
            break;
    }
} /* setTimeTask */


/******************************************************************************************************************************************************
  writeBorderPixels()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::clearBorderPixelsWithoutClockPixels()
{
    for(byte Column = Border.ColumnStart; Column <= Border.ColumnEnd; Column++) {
        if(isPixelPartOfClockWords(ClockWordsTable, Column, Border.RowStart) == false) {
            // set border top
            pDisplay->clearPixelFast(Column, Border.RowStart);
        }
        if(isPixelPartOfClockWords(ClockWordsTable, Column, Border.RowEnd) == false) {
            // set border bottom
            pDisplay->clearPixelFast(Column, Border.RowEnd);
        }
    }
    for(byte Row = Border.RowStart; Row <= Border.RowEnd; Row++) {
        if(isPixelPartOfClockWords(ClockWordsTable, Border.ColumnStart, Row) == false) {
            // set border left
            pDisplay->clearPixelFast(Border.ColumnStart, Row);
        }
        if(isPixelPartOfClockWords(ClockWordsTable, Border.ColumnEnd, Row) == false) {
            // set border right
            pDisplay->clearPixelFast(Border.ColumnEnd, Row);
        }
    }
} /* writeBorderPixels */


/******************************************************************************************************************************************************
  writeBorderPixels()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::writeBorderPixels(bool Value)
{
    for(byte Column = Border.ColumnStart; Column <= Border.ColumnEnd; Column++) {
        // set border top
        pDisplay->writePixelFast(Column, Border.RowStart, Value);
        // set border bottom
        pDisplay->writePixelFast(Column, Border.RowEnd, Value);
    }
    for(byte Row = Border.RowStart; Row <= Border.RowEnd; Row++) {
        // set border left
        pDisplay->writePixelFast(Border.ColumnStart, Row, Value);
        // set border right
        pDisplay->writePixelFast(Border.ColumnEnd, Row, Value);
    }
} /* writeBorderPixels */


/******************************************************************************************************************************************************
  increaseBorder()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockCube::increaseBorder()
{
    stdReturnType ReturnValue = E_OK;

    if(Border.ColumnStart > 0) { Border.ColumnStart--; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.ColumnEnd < DISPLAY_NUMBER_OF_COLUMNS - 1) { Border.ColumnEnd++; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.RowStart > 0) { Border.RowStart--; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.RowEnd < DISPLAY_NUMBER_OF_ROWS - 1) { Border.RowEnd++; }
    else { ReturnValue = E_NOT_OK; }

    return ReturnValue;
} /* increaseBorder */


/******************************************************************************************************************************************************
  decreaseBorder()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
stdReturnType AnimationClockCube::decreaseBorder()
{
    stdReturnType ReturnValue = E_OK;

    if(Border.ColumnStart < ANIMATION_CLOCK_CUBE_COLUMN_START_MAX_VALUE) { Border.ColumnStart++; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.ColumnEnd > ANIMATION_CLOCK_CUBE_COLUMN_END_MIN_VALUE) {Border. ColumnEnd--; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.RowStart < ANIMATION_CLOCK_CUBE_ROW_START_MAX_VALUE) { Border.RowStart++; }
    else { ReturnValue = E_NOT_OK; }
    if(Border.RowEnd > ANIMATION_CLOCK_CUBE_ROW_END_MIN_VALUE) { Border.RowEnd--; }
    else { ReturnValue = E_NOT_OK; }

    return ReturnValue;
} /* decreaseBorder */


/******************************************************************************************************************************************************
  setMaxBorder()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::setMaxBorder()
{
    Border.ColumnStart = 0;
    Border.ColumnEnd = DISPLAY_NUMBER_OF_COLUMNS - 1;
    Border.RowStart = 0;
    Border.RowEnd = DISPLAY_NUMBER_OF_ROWS - 1;
    BorderState = BORDER_STATE_MAX;
} /* setMaxBorder */


/******************************************************************************************************************************************************
  setMinBorder()
******************************************************************************************************************************************************/
/*! \brief
 *  \details
 *
 *  \return         -
******************************************************************************************************************************************************/
void AnimationClockCube::setMinBorder()
{
    Border.ColumnStart = ANIMATION_CLOCK_CUBE_COLUMN_START_MAX_VALUE;
    Border.ColumnEnd = ANIMATION_CLOCK_CUBE_COLUMN_END_MIN_VALUE;
    Border.RowStart = ANIMATION_CLOCK_CUBE_ROW_START_MAX_VALUE;
    Border.RowEnd = ANIMATION_CLOCK_CUBE_ROW_END_MIN_VALUE;
    BorderState = BORDER_STATE_MIN;
} /* setMinBorder */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
