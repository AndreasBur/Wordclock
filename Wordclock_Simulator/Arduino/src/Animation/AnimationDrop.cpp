/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationDrop.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_DROP_SOURCE_

/******************************************************************************************************************************************************
 * INCLUDES
******************************************************************************************************************************************************/
#include "AnimationDrop.h"


/******************************************************************************************************************************************************
 *  LOCAL CONSTANT MACROS
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  LOCAL FUNCTION MACROS
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  LOCAL DATA TYPES AND STRUCTURES
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  init()
******************************************************************************************************************************************************/
void AnimationDrop::init()
{
    AnimationCommon::init(STATE_IDLE);
    reset();
} /* init */


/******************************************************************************************************************************************************
  setTime()
******************************************************************************************************************************************************/
StdReturnType AnimationDrop::setTime(byte Hour, byte Minute)
{
    StdReturnType returnValue{E_NOT_OK};

    if(Clock::getInstance().getClockWords(Hour, Minute, ClockWordsTable) == E_OK && State == STATE_IDLE) {
        setNextWordIndex();
        if(setNextActivePixelIndex() == E_NOT_OK) { setStateToSetTime(); }
        else { State = STATE_CLEAR_TIME; }
    }
    return returnValue;
} /* setTime */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
void AnimationDrop::task()
{
    if(State == STATE_CLEAR_TIME) { clearTimeTask(); }
    else if(State == STATE_SET_TIME) { setTimeTask(); }
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
void AnimationDrop::reset()
{
    Row = 0u;
    Column = 0u;
    ClockWordsTable.fill(DisplayWords::WORD_NONE);
    CurrentWordIndex = ClockWordsTable.size() - 1u;
} /* reset */


/******************************************************************************************************************************************************
  clearTimeTask()
******************************************************************************************************************************************************/
void AnimationDrop::clearTimeTask()
{
    // toggle current Pixel
    if(Row < DISPLAY_NUMBER_OF_ROWS && Column < DISPLAY_NUMBER_OF_COLUMNS) { Display::getInstance().togglePixelFast(Column, Row); }
    // increment row and check for out of bounds
    if(Row + 1u < DISPLAY_NUMBER_OF_ROWS) {
        // toggle Pixel in next row
        Row++;
        Display::getInstance().togglePixelFast(Column, Row);
    } else {
        // no more active pixels available
        if(setNextActivePixelIndex() == E_NOT_OK) { setStateToSetTime(); }
    }
} /* clearTimeTask */


/******************************************************************************************************************************************************
  setTimeTask()
******************************************************************************************************************************************************/
void AnimationDrop::setTimeTask()
{
    DisplayWord currentWord = Words.getDisplayWordFast(ClockWordsTable[CurrentWordIndex]);
    const byte maxColumn = Words.getDisplayWordColumnFast(ClockWordsTable[CurrentWordIndex]) + currentWord.getLength() - 1u;

    if(setNextRow(currentWord.getRow()) == E_OK) {
        Display::getInstance().clearPixelFast(Column, Row - 1u);
    } else {
        if(setNextColumn(maxColumn) == E_NOT_OK) {
            State = STATE_IDLE;
            reset();
        }
    }
    Display::getInstance().setPixelFast(Column, Row);
} /* setTimeTask */


/******************************************************************************************************************************************************
  getNextActivePixel()
******************************************************************************************************************************************************/
StdReturnType AnimationDrop::setNextActivePixelIndex()
{
    for(int16_t index = DISPLAY_NUMBER_OF_PIXELS - 1u; index >= 0; index--) {
        if(Display::getInstance().getPixelFast(index)) {
            Display::getInstance().indexToColumnAndRow(index, Column, Row);
            return E_OK;
        }
    }
    return E_NOT_OK;
}


/******************************************************************************************************************************************************
  setNextWordIndex()
******************************************************************************************************************************************************/
StdReturnType AnimationDrop::setNextWordIndex()
{
    for(int8_t index = CurrentWordIndex - 1u; index >= 0; index--) {
        if(ClockWordsTable[index] != DisplayWords::WORD_NONE) {
            CurrentWordIndex = index;
            return E_OK;
        }
    }
    return E_NOT_OK;
} /* setNextWordIndex */


/******************************************************************************************************************************************************
  setStateToSetTime()
******************************************************************************************************************************************************/
void AnimationDrop::setStateToSetTime()
{
    Row = 0u;
    Column = Words.getDisplayWordColumnFast(ClockWordsTable[CurrentWordIndex]);
    Display::getInstance().setPixelFast(Column, Row);
    State = STATE_SET_TIME;
} /* setStateToSetTime */


/******************************************************************************************************************************************************
  setNextRow()
******************************************************************************************************************************************************/
StdReturnType AnimationDrop::setNextRow(byte MaxRow)
{
    if(Row >= MaxRow) {
        return E_NOT_OK;
    } else {
        Row++;
        return E_OK;
    }
} /* setNextRow */


/******************************************************************************************************************************************************
  setNextColumn()
******************************************************************************************************************************************************/
StdReturnType AnimationDrop::setNextColumn(byte MaxColumn)
{
    if(Column >= MaxColumn) {
         if(setNextWordIndex() == E_OK) {
            Column = Words.getDisplayWordColumnFast(ClockWordsTable[CurrentWordIndex]);
            Row = 0u;
            return E_OK;
        } else {
            return E_NOT_OK;
        }
    } else {
        Column++;
        Row = 0u;
        return E_OK;
    }
} /* setNextColumn */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
