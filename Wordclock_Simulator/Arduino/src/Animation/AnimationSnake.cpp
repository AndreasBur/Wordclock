/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationSnake.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_SNAKE_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "AnimationSnake.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  init()
******************************************************************************************************************************************************/
void AnimationSnake::init()
{
    AnimationCommon::init(STATE_IDLE);
    reset();
} /* init */


/******************************************************************************************************************************************************
  setTime()
******************************************************************************************************************************************************/
StdReturnType AnimationSnake::setTime(byte Hour, byte Minute)
{
    StdReturnType returnValue{E_NOT_OK};

    if(Clock::getInstance().getClockWords(Hour, Minute, ClockWordsTable) == E_OK && State == STATE_IDLE) {
        returnValue = E_OK;
        SnakeBeginIndex = 0u;
        SnakeEndIndex = 0u;
        State = STATE_SET_TIME;
    }
    return returnValue;
} /* setTime */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
void AnimationSnake::task()
{
    if(State == STATE_SET_TIME) {
        byte snakeEndIndexTrans = transformToSerpentine(SnakeEndIndex);
        Display::getInstance().setPixelFast(transformToSerpentine(SnakeBeginIndex));

        if((SnakeBeginIndex - SnakeEndIndex) == ANIMATION_SNAKE_LENGTH ||
           (SnakeBeginIndex >= DISPLAY_NUMBER_OF_LEDS - 1u && SnakeEndIndex < DISPLAY_NUMBER_OF_LEDS))
        {
            //Display::getInstance().clearPixelFast(SnakeEndIndexTrans);
            if(isPixelPartOfClockWords(ClockWordsTable, snakeEndIndexTrans) == false) Display::getInstance().clearPixelFast(snakeEndIndexTrans);
            SnakeEndIndex++;
        }
        if(SnakeBeginIndex < DISPLAY_NUMBER_OF_LEDS - 1u) SnakeBeginIndex++;
        if(SnakeEndIndex >= DISPLAY_NUMBER_OF_LEDS) State = STATE_IDLE;
    }
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
void AnimationSnake::reset()
{
    SnakeBeginIndex = 0u;
    SnakeEndIndex = 0u;
    SnakeState = SNAKE_STATE_TO_RIGHT;
} /* reset */


/******************************************************************************************************************************************************
  transformToSerpentine()
******************************************************************************************************************************************************/
byte AnimationSnake::transformToSerpentine(byte Column, byte Row) const
{
    byte index;

    if(IS_BIT_CLEARED(Row, 0u)) index = (Row * DISPLAY_NUMBER_OF_COLUMNS) + Column;
    else index = (Row * DISPLAY_NUMBER_OF_COLUMNS) + (DISPLAY_NUMBER_OF_COLUMNS - Column - 1u);

    return index;
} /* transformToSerpentine */


/******************************************************************************************************************************************************
  transformToSerpentine()
******************************************************************************************************************************************************/
byte AnimationSnake::transformToSerpentine(byte Index) const
{
    byte column = Display::getInstance().indexToColumn(Index);
    byte row = Display::getInstance().indexToRow(Index);

    return transformToSerpentine(column, row);
} /* transformToSerpentine */

/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
