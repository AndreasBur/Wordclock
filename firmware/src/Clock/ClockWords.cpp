/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       ClockWords.cpp
 *      \brief      
 *
 *      \details    
 *                  
 *
******************************************************************************************************************************************************/
#define _CLOCKWORDS_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "ClockWords.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S 
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Operator ==
******************************************************************************************************************************************************/
bool ClockWords::operator==(const ClockWords& clock_words) const
{
    if(show_it_is_    == clock_words.GetShowItIs()    &&
       hour_words_   == clock_words.GetHourWords()   &&
       minute_words_ == clock_words.GetMinuteWords() )
    {
        return true;
    } else {
        return false;
    }
}

/******************************************************************************************************************************************************
  Operator !=
******************************************************************************************************************************************************/
bool ClockWords::operator!=(const ClockWords& clock_words) const
{
    if(operator==(clock_words)) { return false; }
    else { return true; }
}

/******************************************************************************************************************************************************
  getWordsList()
******************************************************************************************************************************************************/
ClockWords::WordsListType ClockWords::GetWordsList() const
{
    /* ----- Local Variables ---------------------------------------------- */
    WordsListType clock_words;
    byte clock_words_index{0};

    /* ----- Implementation ----------------------------------------------- */  
    if(show_it_is_) {
        clock_words[clock_words_index++] = DisplayWords::kWordEs;
        clock_words[clock_words_index++] = DisplayWords::kWordIst;
    }
    for(uint8_t index = 0; index < CLOCK_WORDS_MAX_NUMBER_OF_MINUTE_WORDS; index++) {
        if(minute_words_[index] != DisplayWords::kWordNone) {
            clock_words[clock_words_index++] = minute_words_[index];
        }
    }
    for(uint8_t index = 0; index < CLOCK_WORDS_MAX_NUMBER_OF_HOUR_WORDS; index++) {
        if(hour_words_[index] != DisplayWords::kWordNone) {
            clock_words[clock_words_index++] = hour_words_[index];
        }
    }
    for(uint8_t index = clock_words_index; index < CLOCK_WORDS_MAX_NUMBER_OF_WORDS; index++) {
        clock_words[index] = DisplayWords::kWordNone;
    }
    return clock_words;
}


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
