/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       Scheduler.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _SCHEDULER_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "Scheduler.h"
#include "Animations.h"
#include "DisplayManager.h"
#include "Illuminance.h"
#include "Communication.h"
#include "Overlays.h"
#include "Persistence.h"
#include "Text.h"

/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
void Scheduler::task()
{
    triggerTasks();
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  isDue()
******************************************************************************************************************************************************/
/*! \brief          Tells whether a task is due on this tick, and counts it down if not
 *  \details        A cycle of zero switches the task off. Its remaining ticks are
 *                  cleared along with it, so switching it back on runs it right away
 *                  instead of somewhere inside a period left over from before.
 *
 *  \return         true if the task is to run on this tick
******************************************************************************************************************************************************/
bool Scheduler::isDue(TaskIdType TaskId, byte Cycle) {
    if(Cycle == 0u) { RemainingTicks[TaskId] = 0u; return false; }
    if(RemainingTicks[TaskId] > 1u) { RemainingTicks[TaskId]--; return false; }

    /* Reloading here rather than on the previous run is what makes a cycle that changed
       in between take effect. Starting from zero, every task is due on the first tick. */
    RemainingTicks[TaskId] = Cycle;
    return true;
} /* isDue */


/******************************************************************************************************************************************************
  triggerTasks()
******************************************************************************************************************************************************/
void Scheduler::triggerTasks()
{
    if(isDue(TASK_ID_ILLUMINANCE, Illuminance::getInstance().getTaskCycle())) { Illuminance::getInstance().task(); }
    /* after the sensor, so the brightness automatic works on a fresh reading */
    if(isDue(TASK_ID_DISPLAY_MANAGER, DisplayManager::getInstance().getTaskCycle())) { DisplayManager::getInstance().task(); }
    if(isDue(TASK_ID_ANIMATIONS, Animations::getInstance().getTaskCycle())) { Animations::getInstance().task(true); }
    if(isDue(TASK_ID_COMMUNICATION, Communication::getInstance().getTaskCycle())) { Communication::getInstance().task(); }
    if(isDue(TASK_ID_OVERLAYS, Overlays::getInstance().getTaskCycle())) { Overlays::getInstance().task(); }
    if(isDue(TASK_ID_TEXT, Text::getInstance().getTaskCycle())) { Text::getInstance().task(true); }
    /* last, so what it compares against the store is a settled state rather than one from
       the middle of this tick's pass */
    if(isDue(TASK_ID_PERSISTENCE, Persistence::getInstance().getTaskCycle())) { Persistence::getInstance().task(); }
} /* triggerTasks */

/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
