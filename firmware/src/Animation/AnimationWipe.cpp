/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationWipe.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_WIPE_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "AnimationWipe.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Init()
******************************************************************************************************************************************************/
void AnimationWipe::Init()
{
    Animation::Init(kStateIdle);
    Reset();
} /* Init */


/******************************************************************************************************************************************************
  SetTime()
******************************************************************************************************************************************************/
StdReturnType AnimationWipe::SetTime(byte hour, byte minute)
{
    StdReturnType return_value{kENotOk};

    if(Clock::GetInstance().GetClockWords(hour, minute, clock_words_table_) == kEOk && state_ == kStateIdle) {
        return_value = kEOk;
        state_ = kStateClearTime;
    }
    return return_value;
} /* SetTime */


/******************************************************************************************************************************************************
  Task()
******************************************************************************************************************************************************/
void AnimationWipe::Task()
{
    if(state_ == kStateClearTime) { ClearTimeTask(); }
    else if(state_ == kStateSetTime) { SetTimeTask(); }
} /* Task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Reset()
******************************************************************************************************************************************************/
void AnimationWipe::Reset()
{
    clock_words_table_.fill(DisplayWords::kWordNone);
    index_ = 0u;
    set_pixel_state_ = kSetPixelStateDown;
} /* Reset */


/******************************************************************************************************************************************************
  ClearTimeTask()
******************************************************************************************************************************************************/
void AnimationWipe::ClearTimeTask()
{
    byte column, row;

    Display::GetInstance().IndexToColumnAndRow(index_, column, row);

    do {
        if(Display::GetInstance().GetPixel(column, row)) {
            if(set_pixel_state_ == kSetPixelStateDown) { SetPixelDown(column, row); }
            else { SetPixelRight(column, row); }
        }
    } while(column-- != 0u && row++ < DISPLAY_NUMBER_OF_ROWS - 1u);

    if(set_pixel_state_ == kSetPixelStateDown) { set_pixel_state_ = kSetPixelStateRight; }
    else { set_pixel_state_ = kSetPixelStateDown; }

    if(SetNextIndex() == kENotOk) {
        index_ = 0u;
        state_ = kStateSetTime;
    }
} /* ClearTimeTask */


/******************************************************************************************************************************************************
  SetTimeTask()
******************************************************************************************************************************************************/
void AnimationWipe::SetTimeTask()
{
    byte column, row;

    Display::GetInstance().IndexToColumnAndRow(index_, column, row);

    do {
        if(IsPixelPartOfClockWords(clock_words_table_, column, row)) {
            Display::GetInstance().SetPixel(column, row);
        }
    } while(column-- != 0u && row++ < DISPLAY_NUMBER_OF_ROWS - 1u);

    if(SetNextIndex() == kENotOk) {
        FinishWithClockWords(clock_words_table_);
    }
} /* SetTimeTask */


/******************************************************************************************************************************************************
  SetNextIndex()
******************************************************************************************************************************************************/
StdReturnType AnimationWipe::SetNextIndex()
{
    StdReturnType return_value = kEOk;
    byte column, row;

    Display::GetInstance().IndexToColumnAndRow(index_, column, row);

    if(column < DISPLAY_NUMBER_OF_COLUMNS - 1u) column++;
    else if(row < DISPLAY_NUMBER_OF_ROWS - 1u) row++;
    else return_value = kENotOk;

    index_ = Display::GetInstance().ColumnAndRowToIndex(column, row);
    return return_value;
} /* SetNextIndex */


/******************************************************************************************************************************************************
  SetPixelDown()
******************************************************************************************************************************************************/
void AnimationWipe::SetPixelDown(byte column, byte row)
{
    Display::GetInstance().ClearPixel(column, row);

    for(byte row_next = row + 1u; row_next < DISPLAY_NUMBER_OF_ROWS; row_next++) {
        if(Display::GetInstance().GetPixel(column, row_next) == false) {
            Display::GetInstance().SetPixel(column, row_next);
            break;
        }
    }
} /* SetPixelDown */


/******************************************************************************************************************************************************
  SetPixelRight()
******************************************************************************************************************************************************/
void AnimationWipe::SetPixelRight(byte column, byte row)
{
    Display::GetInstance().ClearPixel(column, row);

    for(byte column_next = column + 1u; column_next < DISPLAY_NUMBER_OF_COLUMNS; column_next++) {
        if(Display::GetInstance().GetPixel(column_next, row) == false) {
            Display::GetInstance().SetPixel(column_next, row);
            break;
        }
    }
} /* SetPixelRight */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
