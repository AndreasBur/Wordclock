/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationTeletype.cpp
 *      \brief      
 *
 *      \details    
 *                  
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_TELETYPE_SOURCE_

/******************************************************************************************************************************************************
 * INCLUDES
******************************************************************************************************************************************************/
#include "AnimationTeletype.h"


/******************************************************************************************************************************************************
 *  LOCAL CONSTANT MACROS
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  LOCAL FUNCTION MACROS
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  LOCAL DATA TYPES AND STRUCTURES
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Init()
******************************************************************************************************************************************************/
void AnimationTeletype::Init()
{
    Animation::Init(kStateIdle);
    Reset();
} /* init */


/******************************************************************************************************************************************************
  setTime()
******************************************************************************************************************************************************/
StdReturnType AnimationTeletype::SetTime(byte hour, byte minute)
{
    StdReturnType return_value{kENotOk};

    if(Clock::GetInstance().GetClockWords(hour, minute, clock_words_table_) == kEOk && state_ == kStateIdle) {
        return_value = kEOk;
        current_word_index_ = 0u;
        current_char_index_ = 0u;
        current_word_length_ = words_.GetDisplayWordLength(clock_words_table_[current_word_index_]);
        state_ = kStateSetTime;
    }
    return return_value;
} /* setTime */


/******************************************************************************************************************************************************
  task()
******************************************************************************************************************************************************/
void AnimationTeletype::Task()
{
    if(state_ == kStateSetTime) {
        if(current_char_index_ >= current_word_length_) {
            if(SetNextWordIndex() == kENotOk) {
                FinishWithClockWords(clock_words_table_);
                return;
            }
            current_char_index_ = 0u;
            current_word_length_ = words_.GetDisplayWordLength(clock_words_table_[current_word_index_]);
        }
        current_char_index_++;
        Display::GetInstance().SetWord(clock_words_table_[current_word_index_], current_char_index_);
    }
} /* task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  reset()
******************************************************************************************************************************************************/
void AnimationTeletype::Reset()
{
    clock_words_table_.fill(DisplayWords::kWordNone);
    current_word_index_ = 0u;
    current_word_length_ = 0u;
    current_char_index_ = 0u;
} /* reset */


/******************************************************************************************************************************************************
  setNextWordIndex()
******************************************************************************************************************************************************/
StdReturnType AnimationTeletype::SetNextWordIndex()
{
    if(current_word_index_ + 1u < static_cast<byte>(clock_words_table_.size())) {
        current_word_index_++;
        return kEOk;
    }
    return kENotOk;
} /* setNextWordIndex */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
