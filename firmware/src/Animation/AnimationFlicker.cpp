/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationFlicker.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_FLICKER_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "AnimationFlicker.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Init()
******************************************************************************************************************************************************/
void AnimationFlicker::Init()
{
    Animation::Init(StateType::kIdle);
    Reset();
} /* Init */


/******************************************************************************************************************************************************
  SetTime()
******************************************************************************************************************************************************/
StdReturnType AnimationFlicker::SetTime(byte hour, byte minute)
{
    StdReturnType return_value{kENotOk};

    if(hour < CLOCK_NUMBER_OF_HOURS_PER_DAY && minute < CLOCK_NUMBER_OF_MINUTES_PER_HOUR) {
        hour_ = hour;
        minute_ = minute;
        state_ = StateType::kClearTime;
        return_value = kEOk;
    }
    return return_value;
} /* SetTime */


/******************************************************************************************************************************************************
  Task()
******************************************************************************************************************************************************/
void AnimationFlicker::Task()
{
    if(state_ == StateType::kClearTime) { ClearTimeTask(); }
    else if(state_ == StateType::kSetTime) { SetTimeTask(); }
} /* Task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Reset()
******************************************************************************************************************************************************/
void AnimationFlicker::Reset()
{
    /* The flicker is made by switching the display off and on, and it ends on an off:
       ClearTimeTask() toggles first and only then decides whether it was the last run, so
       the final toggle is always the one that darkens. Nothing switched it back, which
       left a clock that had shown this animation dark until something else happened to
       turn it on.

       Here rather than at the end of the animation, because Reset() is also where an
       abort lands - a flicker cut short in the middle had the same ending. */
    Display::GetInstance().Enable();

    minute_ = 0u;
    hour_ = 0u;
    is_clock_set_ = false;
    flicker_counter_ = ANIMATION_FLICKER_COUNTER_INIT_VALUE;
} /* Reset */


/******************************************************************************************************************************************************
  ClearTimeTask()
******************************************************************************************************************************************************/
void AnimationFlicker::ClearTimeTask()
{

    is_clock_set_ = !is_clock_set_;

    if(is_clock_set_) {
        Display::GetInstance().Disable();
    } else {
        Display::GetInstance().Enable();
    }

    if(flicker_counter_-- <= 0u) state_ = StateType::kSetTime;
} /* ClearTimeTask */


/******************************************************************************************************************************************************
  SetTimeTask()
******************************************************************************************************************************************************/
void AnimationFlicker::SetTimeTask()
{
    /* before Reset(), which clears Hour and Minute */
    FinishWithTime(hour_, minute_);
    Reset();
} /* SetTimeTask */

/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
