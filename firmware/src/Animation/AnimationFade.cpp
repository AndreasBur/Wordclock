/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       AnimationFade.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_CLOCK_FADE_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "AnimationFade.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Init()
******************************************************************************************************************************************************/
void AnimationFade::Init()
{
    Animation::Init(kStateIdle);
    Reset();
} /* Init */


/******************************************************************************************************************************************************
  SetTime()
******************************************************************************************************************************************************/
StdReturnType AnimationFade::SetTime(byte hour, byte minute)
{
    StdReturnType return_value{kENotOk};

    if(hour < CLOCK_NUMBER_OF_HOURS_PER_DAY && minute < CLOCK_NUMBER_OF_MINUTES_PER_HOUR) {
        hour_ = hour;
        minute_ = minute;
        state_ = kStateClearTime;
        /* From the display as it is configured, whatever that currently is - the fade
           scales it rather than replacing it. */
        level_ = kLevelFull;
        return_value = kEOk;
    }
    return return_value;
} /* SetTime */


/******************************************************************************************************************************************************
  Task()
******************************************************************************************************************************************************/
void AnimationFade::Task()
{
    if(state_ == kStateClearTime) { ClearTimeTask(); }
    else if(state_ == kStateSetTime) { SetTimeTask(); }
} /* Task */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  Reset()
******************************************************************************************************************************************************/
/*! \brief          Back to a display nobody is fading
 *  \details        Called from Init(), which is also what an aborted animation goes
 *                  through - a fade that was cut off half way would otherwise leave the
 *                  display dimmed with nothing left to undim it.
******************************************************************************************************************************************************/
void AnimationFade::Reset()
{
    level_ = kLevelFull;
    hour_ = 0u;
    minute_ = 0u;
    Display::GetInstance().ClearBrightnessFade();
} /* Reset */


/******************************************************************************************************************************************************
  ClearTimeTask()
******************************************************************************************************************************************************/
void AnimationFade::ClearTimeTask()
{
    if(level_ > 0u) {
        level_--;
        Display::GetInstance().SetBrightnessFadeLevel(level_);
    } else {
        SetStateToSetTime();
    }
} /* ClearTimeTask */


/******************************************************************************************************************************************************
  SetTimeTask()
******************************************************************************************************************************************************/
void AnimationFade::SetTimeTask()
{
    if(level_ < kLevelFull) {
        level_++;
        Display::GetInstance().SetBrightnessFadeLevel(level_);
    } else {
        /* Cleared rather than left at full: a level that is set at all costs a comparison
           on every ApplyBrightness(), and leaving it set would hide a fade that never
           finished. */
        Display::GetInstance().ClearBrightnessFade();
        state_ = kStateIdle;
    }
} /* SetTimeTask */


/******************************************************************************************************************************************************
  SetStateToSetTime()
******************************************************************************************************************************************************/
/*! \brief          Swaps the time behind a display that is dark
 *  \details        The clear is what was missing: setting the new time writes its letters,
 *                  it does not take the previous ones away, so both were lit at once - and
 *                  at the moment of the swap the display is black, which is the one moment
 *                  where nobody can see it happen.
******************************************************************************************************************************************************/
void AnimationFade::SetStateToSetTime()
{
    state_ = kStateSetTime;
    Display::GetInstance().Clear();
    Clock::GetInstance().SetTime(hour_, minute_);
    level_ = 0u;
} /* SetStateToSetTime */


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
