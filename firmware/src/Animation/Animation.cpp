/******************************************************************************************************************************************************
 *  COPYRIGHT
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  \verbatim
 *  Copyright (c) Andreas Burnickl                                                                                                 All rights reserved.
 *
 *  \endverbatim
 *  ---------------------------------------------------------------------------------------------------------------------------------------------------
 *  FILE DESCRIPTION
 *  -------------------------------------------------------------------------------------------------------------------------------------------------*/
/**     \file       Animation.cpp
 *      \brief
 *
 *      \details
 *
 *
******************************************************************************************************************************************************/
#define _ANIMATION_SOURCE_

/******************************************************************************************************************************************************
 * I N C L U D E S
******************************************************************************************************************************************************/
#include "Animation.h"


/******************************************************************************************************************************************************
 *  L O C A L   C O N S T A N T   M A C R O S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  L O C A L   F U N C T I O N   M A C R O S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 *  L O C A L   D A T A   T Y P E S   A N D   S T R U C T U R E S
******************************************************************************************************************************************************/



/******************************************************************************************************************************************************
 * P U B L I C   F U N C T I O N S
******************************************************************************************************************************************************/

/******************************************************************************************************************************************************
  isPixelPartOfClockWords()
******************************************************************************************************************************************************/
bool Animation::IsPixelPartOfClockWords(const ClockWords::WordsListType clock_words_table, byte column, byte row)
{
    DisplayWords words;

    for(uint8_t word_index = 0u; word_index < clock_words_table.size(); word_index++) {
        if(clock_words_table[word_index] == DisplayWords::kWordNone) { break; }
        DisplayWord word = words.GetDisplayWord(clock_words_table[word_index]);
        if(word.GetRow() == row) { if((column >= word.GetColumn()) && (column < word.GetColumn() + word.GetLength())) { return true; } }
    }
    return false;
} /* isPixelPartOfWord */

/******************************************************************************************************************************************************
  isPixelPartOfClockWords()
******************************************************************************************************************************************************/
bool Animation::IsPixelPartOfClockWords(const ClockWords::WordsListType clock_words_table, byte index)
{
    byte row = index / DISPLAY_NUMBER_OF_COLUMNS;
    byte column = index % DISPLAY_NUMBER_OF_COLUMNS;

    return IsPixelPartOfClockWords(clock_words_table, column, row);
} /* isPixelPartOfWord */


/******************************************************************************************************************************************************
  selectByTime()
******************************************************************************************************************************************************/
byte Animation::SelectByTime(byte hour, byte minute, byte number_of_values)
{
    /* Lets an animation vary from minute to minute without keeping a random generator
       of its own. A plain modulo of the minute would not do, because it walks through
       the values in a fixed order; two multiplications with an xor fold in between
       scatter them as a random generator would. */
    byte hash = static_cast<byte>(((hour * 60u) + minute) * kSelectHashFactor);
    hash ^= static_cast<byte>(hash >> 4u);
    hash = static_cast<byte>(hash * kSelectHashFactor);

    /* scaled by multiplication instead of a modulo, which would favour the lower
       values because 256 is not a multiple of NumberOfValues */
    return static_cast<byte>((static_cast<uint16_t>(hash) * number_of_values) >> 8u);
} /* selectByTime */


/******************************************************************************************************************************************************
 * P R I V A T E   F U N C T I O N S
******************************************************************************************************************************************************/


/******************************************************************************************************************************************************
 *  E N D   O F   F I L E
******************************************************************************************************************************************************/
